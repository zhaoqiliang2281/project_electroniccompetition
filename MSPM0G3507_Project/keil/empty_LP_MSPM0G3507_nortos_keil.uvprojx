# Keil uVision project empty_LP_MSPM0G3507_nortos_keil.uvprojx, settings and files
target MSPM0G3507Project (6220000::V6.22::ARMCLANG)
  device: MSPM0G3507 Texas Instruments
  pack: TexasInstruments.MSPM0G1X0X_G3X0X_DFP.1.3.1
  cpu: IRAM(0x20000000,0x00008000) IRAM2(0x20100000,0x00008000) IROM(0x00000000,0x00020000) IROM2(0x00400000,0x00020000) XRAM(0x20200000,0x00008000) XRAM2(0x20300000,0x00008000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: empty_LP_MSPM0G3507_nortos_keil +hex
  BeforeMake: cmd.exe /C "D:/ti/mspm0_sdk_2_01_00_03/tools/keil/syscfg.bat '$P' empty.syscfg"
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=4
  c define: __MSPM0G3507__
  c include: D:\ti\mspm0_sdk_2_01_00_03\source\third_party\CMSIS\Core\Include;D:\ti\mspm0_sdk_2_01_00_03\source;..\..\project;..\OLED;..\System;..\Hardware;..\MPU6050;..\IMU660RB;..\Fusion;..\User
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT5: ROM 0x400000 size 0x20000
  memory RVCT6: RAM 0x20200000 size 0x8000
  memory RVCT7: RAM 0x20300000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x8000
  memory RVCT10: RAM 0x20100000 size 0x8000
  scatter file: ./mspm0g3507.sct
  link misc: D:/ti/mspm0_sdk_2_01_00_03/source/ti/driverlib/lib/keil/m0p/mspm0g1x0x_g3x0x/driverlib.a
  group OLED
    ../OLED/: OLED.c OLED.h OLED_Font.h
  group Hardware
    ../Hardware/: Motor.c Motor.h PWM.c PWM.h Servo.c Servo.h grayscale_sensor.c grayscale_sensor.h JY901S.c JY901S.h
  group System
    ../System/: Delay.c Delay.h key.c key.h RGB.c RGB.h Serial.c Serial.h PID.c PID.h
  group User
    ./: startup_mspm0g350x_uvision.s
    ../User/: All_include.h main.c Readme.md ti_msp_dl_config.c ti_msp_dl_config.h
