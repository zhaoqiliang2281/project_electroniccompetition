# Keil uVision project Diansai.uvprojx, settings and files
target Diansai (5060528::V5.06 update 5 (build 528)::.\ARMCC)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.0.0
  cpu: IRAM(0x20000000-0x2001BFFF) IRAM2(0x2001C000-0x2001FFFF) IROM(0x8000000-0x807FFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: Diansai +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx
  c include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;../Ground;../applicantion;../contorller;../boards;../OLED;../System;../Hardware;../nrf24l01
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x1c000
  memory RVCT10: RAM 0x2001c000 size 0x4000
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_can.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group Application/User/Core
    ../Core/Src/: main.c gpio.c can.c dma.c tim.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c
  group Ground
    ../Ground/: Emm_V5.c Emm_V5.h motor.c motor.h
  group applicantion
    ../applicantion/: chassis_behaviour.c chassis_behaviour.h chassis_task.c chassis_task.h
  group contorller
    ../contorller/: delay.c delay.h pid.c pid.h struct_typedef.h
  group boards
    ../boards/: HWT101.c HWT101.h
  group OLED
    ../OLED/: OLED.c OLED.h OLED_Font.h
  group System
    ../System/: Serial.c Serial.h Serial2.c Serial2.h Subject.c Subject.h
  group Hardware
    ../Hardware/: Buzzer.c Buzzer.h Key.c Key.h LED.c LED.h douji.c douji.h Dloud_deck.c Dloud_deck.h
software components: CMSIS:CORE 4.3.0
